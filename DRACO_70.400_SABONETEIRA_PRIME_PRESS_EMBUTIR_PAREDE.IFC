Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.400_SABONETEIRA_PRIME_PRESS_EMBUTIR_PAREDE.IFC
Time: 2023-11-30T18:38:30
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.400_SABONETEIRA_PRIME_PRESS_EMBUTIR_PAREDE
In: Default Storey
Material: Steel
PSet_Mass_Property - Mass Measure: 2.43435; Area Measure: 0.175686 m2; Volume Measure: 0.00243435 m3
